# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\STM32F10x_FWLib\inc;.\HAWARE\LED;.\HAWARE\DELAY
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group HAWARE
    ./HAWARE/LED/: LED.c
    ./HAWARE/DELAY/: delay.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
